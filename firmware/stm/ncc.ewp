# IAR project ncc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: source; source\cmsis\Include; source\..\..\common\source; source\cmsis\Device\ST\STM32F1xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: ncc.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F103xB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: firmware.hex
  group (top)
    ../common/source/: datetime.cpp ipc.cpp list.cpp
    source/: debug.cpp event.cpp main.cpp ntime.cpp random.cpp storage.cpp timer.cpp wifi.cpp
  group hmi
    source/: display.cpp hmi.cpp led.cpp neon.cpp nixie.cpp screen.cpp
  group include
    ../common/source/: common.h xwifi.h
    source/: system.h typedefs.h xmath.h
  group include/proto
    source/proto/: display.inc.h light.inc.h screen.inc.h
    ../common/source/proto/: time.inc.h wifi.inc.h
  group periphery
    source/: esp.cpp i2c.h io.cpp light.cpp mcu.cpp nvic.cpp rtc.cpp temp.cpp wdt.cpp
